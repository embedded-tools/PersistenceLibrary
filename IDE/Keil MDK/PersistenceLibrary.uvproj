# Keil uVision project PersistenceLibrary.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PersistenceLibrary (library)
  c flags: Optim=1
  c include: ..\..\Source\BasicTypes;..\..\Source\Collections;..\..\Source\FileUtils;..\..\Source\Graphics;..\..\Source\Math;..\..\Source\Persistence;..\..\Source\Protocols
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BasicTypes
    ../../Source/BasicTypes/: EscapeSequences.c StringUtils.cpp TDate.cpp TDateTime.cpp TDateTimeCounter.cpp TFilePath.cpp TParamString.cpp TRandom.cpp TShortString.cpp TString.cpp TStringList.cpp TTime.cpp TWideString.cpp UTF8.c
  group Collections
    ../../Source/Collections/: TArray.cpp TDictionary.cpp TEnumerable.cpp TEnumerator.cpp TList.cpp TObjectList.cpp TQueue.cpp TSortedDictionary.cpp TStack.cpp TStaticDictionary.cpp TStaticList.cpp
  group FileUtils
    ../../Source/FileUtils/: TCachedStream.cpp TEEPROMStream.cpp TFileStream.cpp THandleStream.cpp TJsonDoc.cpp TJsonTag.cpp TJsonTagBasePool.cpp TJsonTagDynamicPool.cpp TJsonTagStaticPool.cpp TLZ77.cpp TLZ77Streamed.cpp TMemoryStream.cpp TROMStream.cpp TStream.cpp TTextFile.cpp TXmlDoc.cpp TXmlTag.cpp TXmlTagBasePool.cpp TXmlTagDynamicPool.cpp TXmlTagStaticPool.cpp
  group Graphics
    ../../Source/Graphics/: TCachedWindowsBmpFile.cpp TCanvas.cpp TColorConverter.cpp TColorRGB.cpp TColorYUV.cpp TDisplay320x240x65536.cpp TDxtBlockCreator.cpp TEndlessLine.cpp TFilter3x3.cpp TFilter5x5.cpp TFilter7x7.cpp TFont.cpp TFontCharacter.cpp TGraphicsData.cpp TPixelFormatConverter.cpp TPosition.cpp TRectangle.cpp TSize.cpp TVector.cpp TWindowsBmpFile.cpp
  group Math
    ../../Source/Math/: TFixedPoint16M.cpp TFixedPoint128.cpp TFixedPoint1024.cpp
  group Persistence
    ../../Source/Persistence/: TMainSerializer.cpp TObjectFactory.cpp TSerializedBaseCollection.cpp TSerializedItem.cpp TSerializer.cpp TXMLCache.cpp TXMLParser.cpp TXMLTypes.cpp
  group Protocols
    ../../Source/Protocols/: tbinaryprotocol.cpp ttextprotocol.cpp
  group Logs
    ../../Source/Logs/: TConsoleLog.cpp TCustomLog.cpp TFileLog.cpp TLogBase.cpp
  group Signaling
    ../../Source/Signaling/: TEventReceiver.cpp TEventSender.cpp TEventSerializer.cpp
